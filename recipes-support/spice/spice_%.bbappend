BBCLASSEXTEND_append = "native nativesdk"
PACKAGECONFIG_append_class-native = " opengl"
