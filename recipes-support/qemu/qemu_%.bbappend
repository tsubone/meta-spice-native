DEPENDS_append = " spice"
